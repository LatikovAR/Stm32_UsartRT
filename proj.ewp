# IAR project proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F051x8
  ICCARM.CCIncludePath2: API\Core; API\Drivers; API\StartUp; API; Inc; SRC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: proj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group API/Core
    API/Core/: core_cm0.h core_cmFunc.h core_cmInstr.h stm32f051x8.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group API/StartUp
    API/Startup/: startup_stm32f051x8.s
  group Inc
    Inc/: DS18B20.h F05_RCC.h GPIO.h Main.h NVIC.h
  group SRC
    SRC/: DS18B20.c
